options:
  parameters:
    generate_options: no_gui
    id: server_prompt_for_exit
    output_language: python
    title: server-prompt-for-exit
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: size
  id: variable
  parameters:
    value: '100000'
  states: {}
- name: blocks_file_descriptor_sink_0
  id: blocks_file_descriptor_sink
  parameters:
    fd: '1'
    type: byte
  states: {state: disabled}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: server-prompt-for-exit.out
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_head_0
  id: blocks_head
  parameters:
    num_items: size // 2
    type: byte
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: byte
  states: {}
- name: blocks_udp_source_0
  id: blocks_udp_source
  parameters:
    eof: 'True'
    ipaddr: 127.0.0.1
    port: '5987'
    psize: '1472'
    type: byte
    vlen: '1'
  states: {}

connections:
- [blocks_head_0, '0', blocks_file_descriptor_sink_0, '0']
- [blocks_head_0, '0', blocks_file_sink_0, '0']
- [blocks_throttle_0, '0', blocks_head_0, '0']
- [blocks_udp_source_0, '0', blocks_throttle_0, '0']

metadata:
  file_format: 1
